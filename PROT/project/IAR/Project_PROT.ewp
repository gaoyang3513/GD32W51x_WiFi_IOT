# IAR project Project_PROT.ewp, settings and files
configuration GDM32 (ARM)
  General.OGChipSelectEditMenu: GD32W515xI_TZ GD GD32W515xI_TZ
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: TFM_LVL=1; __thumb2__; DAUTH_CHIP_DEFAULT; PS_ENCRYPTION; PS_ROLLBACK_PROTECTION; ITS_CREATE_FLASH_LAYOUT; ITS_VALIDATE_METADATA_FROM_FLASH; PS_VALIDATE_METADATA_FROM_FLASH; PS_CREATE_FLASH_LAYOUT; T_COSE_USE_PSA_CRYPTO; T_COSE_DISABLE_CONTENT_TYPE; T_COSE_USE_PSA_CRYPTO_FROM_TFM; BOOT_DATA_AVAILABLE; LEGACY_TFM_TLV_HEADER; TFM_PARTITION_TEST_SECURE_SERVICES; TFM_PARTITION_TEST_PS; ENABLE_PROTECTED_STORAGE_SERVICE_TESTS; PS_TEST_NV_COUNTERS; ENABLE_INTERNAL_TRUSTED_STORAGE_SERVICE_TESTS; ENABLE_CRYPTO_SERVICE_TESTS; ENABLE_ATTESTATION_SERVICE_TESTS; ENABLE_PLATFORM_SERVICE_TESTS; ENABLE_AUDIT_LOGGING_SERVICE_TESTS; SERVICES_TEST_S; TFM_CRYPTO_TEST_ALG_CBC; TFM_CRYPTO_TEST_ALG_CCM; TFM_CRYPTO_TEST_ALG_CFB; TFM_CRYPTO_TEST_ALG_CTR; TFM_CRYPTO_TEST_ALG_GCM; GD_MODIFY_TAG
  ICCARM.CCDiagSuppress: Pa050,Pe223,Pe177,Pe550,Pe940
  ICCARM.IExtraOptions: --enum_is_int
  ICCARM.CCIncludePath2: ..\..\..\config; ..\..\..\ROM-EXPORT\mbedtls-2.17.0-rom\include; ..\..\..\ROM-EXPORT\mbedtls-2.17.0-rom\include\mbedtls; ..\..\..\ROM-EXPORT\platform; ..\..\..\ROM-EXPORT\source; ..\..\mbedtls_ns_callable; ..\..\mbedcrypto\tfm_crypto_include; ..\..\trusted-firmware-m; ..\..\trusted-firmware-m\bl2\include; ..\..\trusted-firmware-m\interface\include; ..\..\trusted-firmware-m\lib\ext\qcbor\inc; ..\..\trusted-firmware-m\lib\ext\qcbor\util; ..\..\trusted-firmware-m\lib\ext\t_cose\inc; ..\..\trusted-firmware-m\lib\ext\t_cose\src; ..\..\trusted-firmware-m\platform\ext\cmsis; ..\..\trusted-firmware-m\platform\ext\common; ..\..\trusted-firmware-m\platform\ext\driver; ..\..\trusted-firmware-m\platform\ext\target\gdm32\gd32w51x; ..\..\trusted-firmware-m\platform\ext\target\gdm32\gd32w51x\cmsis_core; ..\..\trusted-firmware-m\platform\ext\target\gdm32\gd32w51x\cmsis_drivers; ..\..\trusted-firmware-m\platform\ext\target\gdm32\gd32w51x\native_drivers; ..\..\trusted-firmware-m\platform\ext\target\gdm32\gd32w51x\native_drivers\timer_cmsdk; ..\..\trusted-firmware-m\platform\ext\target\gdm32\gd32w51x\partition; ..\..\trusted-firmware-m\platform\ext\target\gdm32\gd32w51x\retarget; ..\..\trusted-firmware-m\platform\ext\target\gdm32\gd32w51x\services; ..\..\trusted-firmware-m\platform\include; ..\..\trusted-firmware-m\secure_fw\include; ..\..\trusted-firmware-m\secure_fw\partitions\crypto; ..\..\trusted-firmware-m\secure_fw\partitions\initial_attestation; ..\..\trusted-firmware-m\secure_fw\partitions\internal_trusted_storage; ..\..\trusted-firmware-m\secure_fw\partitions\protected_storage; ..\..\trusted-firmware-m\secure_fw\spm\include; ..\..\trusted-firmware-m\secure_fw\spm\arch\include; ..\..\trusted-firmware-m\secure_fw\spm\model_ipc\include; ..\..\trusted-firmware-m\test\suites\platform; ..\..\..\NSPE\Firmware\CMSIS\GD\GD32W51x\Include; ..\..\..\NSPE\Firmware\GD32W51x_standard_peripheral\Include; ..\..\..\NSPE\WIFI_IOT\app; $TOOLKIT_DIR$\CMSIS\Core\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\WIFI_IOT\app; $TOOLKIT_DIR$\inc\c
  OBJCOPY.OOCOutputFile: Project_PROT.srec
  prebuild: prot_prebuild.bat $PROJ_DIR$ "$TOOLKIT_DIR$"
  postbuild: ..\prot_afterbuild.bat SIP "" DAPLINK $TARGET_DIR$ $TARGET_BNAME$ IAR "$TOOLKIT_DIR$"
  ILINK.IlinkOutputFile: prot.axf
  ILINK.IlinkIcfFile: tfm_common_s.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group gdm32
    ../../trusted-firmware-m/platform/ext/target/gdm32/gd32w51x/native_drivers/: arm_uart_drv.c mpu_armv8m_drv.c
    ../../trusted-firmware-m/platform/ext/target/gdm32/gd32w51x/cmsis_drivers/: Driver_Flash.c Driver_MPC.c Driver_PPC.c Driver_USART.c
    ../../../NSPE/Firmware/GD32W51x_standard_peripheral/Source/: gd32w51x_fmc.c gd32w51x_gpio.c gd32w51x_icache.c gd32w51x_misc.c gd32w51x_qspi.c gd32w51x_rcu.c gd32w51x_trng.c gd32w51x_tzpcu.c gd32w51x_usart.c
    ../../trusted-firmware-m/platform/ext/target/gdm32/gd32w51x/retarget/: platform_retarget_dev.c
    ../../trusted-firmware-m/platform/ext/target/gdm32/gd32w51x/: spm_hal.c target_cfg.c
    ../../trusted-firmware-m/platform/ext/target/gdm32/gd32w51x/iar/: startup_cmsdk_s.s
    ../../../NSPE/Firmware/CMSIS/GD/GD32W51x/Source/: system_gd32w51x.c
    ../../trusted-firmware-m/platform/ext/target/gdm32/gd32w51x/services/src/: tfm_platform_system.c
    ../../trusted-firmware-m/platform/ext/target/gdm32/gd32w51x/native_drivers/timer_cmsdk/: timer_cmsdk.c
    ../../trusted-firmware-m/platform/ext/common/: uart_stdout.c
  group interface/src/log
    ../../trusted-firmware-m/interface/src/log/: tfm_log_raw.c
  group lib/ext/qcbor
    ../../trusted-firmware-m/lib/ext/qcbor/src/: ieee754.c qcbor_decode.c qcbor_encode.c UsefulBuf.c
    ../../trusted-firmware-m/lib/ext/qcbor/util/: qcbor_util.c
  group lib/ext/t_cose
    ../../trusted-firmware-m/lib/ext/t_cose/src/: t_cose_mac0_sign.c t_cose_mac0_verify.c t_cose_parameters.c t_cose_sign1_sign.c t_cose_sign1_verify.c t_cose_util.c
    ../../trusted-firmware-m/lib/ext/t_cose/crypto_adapters/: t_cose_psa_crypto.c
  group mbedtls
    ../../mbedtls_ns_callable/: mbedtls_nsc.c
    ./: psacrypto.a
  group partitions/audit_logging
    ../../trusted-firmware-m/secure_fw/partitions/audit_logging/: audit_core.c tfm_audit_secure_api.c
  group partitions/initial_attestation
    ../../trusted-firmware-m/secure_fw/partitions/initial_attestation/: attest_token.c attestation_core.c attestation_key.c tfm_attestation.c tfm_attestation_req_mngr.c tfm_attestation_secure_api.c
  group partitions/internal_trusted_storage
    ../../trusted-firmware-m/secure_fw/partitions/internal_trusted_storage/flash/: its_flash.c its_flash_info_external.c its_flash_info_internal.c its_flash_nand.c its_flash_nor.c its_flash_ram.c
    ../../trusted-firmware-m/secure_fw/partitions/internal_trusted_storage/flash_fs/: its_flash_fs.c its_flash_fs_dblock.c its_flash_fs_mblock.c
    ../../trusted-firmware-m/secure_fw/partitions/internal_trusted_storage/: its_utils.c tfm_internal_trusted_storage.c tfm_its_req_mngr.c tfm_its_secure_api.c
  group partitions/lib
    ../../trusted-firmware-m/secure_fw/partitions/lib/sprt/: tfm_libsprt_c_memcmp.c tfm_libsprt_c_memcpy.c tfm_libsprt_c_memmove.c
  group partitions/platform
    ../../trusted-firmware-m/secure_fw/partitions/platform/: platform_sp.c tfm_platform_secure_api.c
  group partitions/protected_storage
    ../../trusted-firmware-m/secure_fw/partitions/protected_storage/crypto/: ps_crypto_interface.c
    ../../trusted-firmware-m/secure_fw/partitions/protected_storage/: ps_encrypted_object.c ps_object_system.c ps_object_table.c ps_utils.c tfm_protected_storage.c tfm_ps_req_mngr.c tfm_ps_secure_api.c
    ../../trusted-firmware-m/secure_fw/partitions/protected_storage/nv_counters/: ps_nv_counters.c
  group patitions/crypto
    ../../trusted-firmware-m/secure_fw/partitions/crypto/: crypto_aead.c crypto_alloc.c crypto_asymmetric.c crypto_cipher.c crypto_hash.c crypto_init.c crypto_key.c crypto_key_derivation.c crypto_mac.c tfm_crypto_secure_api.c tfm_mbedcrypto_alt.c
  group platform/common
    ../../trusted-firmware-m/platform/ext/common/template/: attest_hal.c crypto_keys.c nv_counters.c tfm_initial_attestation_key_material.c tfm_rotpk.c
    ../../trusted-firmware-m/platform/ext/common/: tfm_platform.c
  group spm/arch
    ../../trusted-firmware-m/secure_fw/spm/arch/: tfm_arch.c tfm_arch_v8m_main.c
  group spm/init
    ../../trusted-firmware-m/secure_fw/spm/init/: tfm_boot_data.c tfm_core.c
  group spm/model_func
    ../../trusted-firmware-m/secure_fw/spm/model_func/: spm_func.c tfm_core_svcalls_func.c tfm_nspm_func.c tfm_veneers.c
  group spm/model_ipc
    ../../trusted-firmware-m/secure_fw/spm/model_ipc/: spm_ipc.c spm_psa_client_call.c tfm_core_svcalls_ipc.c tfm_message_queue.c tfm_multi_core.c tfm_multi_core_mem_check.c tfm_nspm_ipc.c tfm_pools.c tfm_psa_api_veneers.c tfm_rpc.c tfm_spe_mailbox.c tfm_thread.c tfm_wait.c
  group spm/runtime
    ../../trusted-firmware-m/secure_fw/spm/runtime/: spm_api.c tfm_core_mem_check.c tfm_core_utils.c tfm_secure_api.c tfm_spm_services.c tfm_utils.c
  group test
    ../../trusted-firmware-m/test/suites/attestation/: attest_public_key.c attest_symmetric_iat_decode.c attest_token_decode.c attest_token_decode_common.c attest_token_test.c
    ../../trusted-firmware-m/test/suites/attestation/secure/: attestation_s_interface_testsuite.c symmetric_attest_s_interface_testsuite.c
    ../../trusted-firmware-m/test/suites/audit/secure/: audit_s_interface_testsuite.c
    ../../trusted-firmware-m/test/suites/crypto/secure/: crypto_sec_interface_testsuite.c
    ../../trusted-firmware-m/test/suites/crypto/: crypto_tests_common.c
    ../../trusted-firmware-m/test/suites/ipc/secure/: ipc_s_interface_testsuite.c
    ../../trusted-firmware-m/test/suites/its/: its_tests_common.c
    ../../trusted-firmware-m/test/framework/: non_secure_suites.c secure_suites.c test_framework.c test_framework_helpers.c test_framework_integ_test_helper.c
    ../../trusted-firmware-m/test/suites/platform/secure/: platform_s_interface_testsuite.c
    ../../trusted-firmware-m/test/suites/platform/: platform_tests_common.c
    ../../trusted-firmware-m/test/suites/ps/secure/: ps_rollback_protection_testsuite.c psa_ps_s_interface_testsuite.c psa_ps_s_reliability_testsuite.c
    ../../trusted-firmware-m/test/suites/its/secure/: psa_its_s_interface_testsuite.c psa_its_s_reliability_testsuite.c
    ../../trusted-firmware-m/test/suites/ps/secure/nv_counters/: test_ps_nv_counters.c
    ../../trusted-firmware-m/test/test_services/tfm_ps_test_service/: tfm_ps_test_service.c tfm_ps_test_service_api.c
    ../../trusted-firmware-m/test/test_services/tfm_secure_client_2/: tfm_secure_client_2.c tfm_secure_client_2_api.c
    ../../trusted-firmware-m/test/test_services/tfm_secure_client_service/: tfm_secure_client_service.c tfm_secure_client_service_api.c
