# IAR project Lib_Psacrypto.ewp, settings and files
configuration Library (ARM)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.IExtraOptions: --enum_is_int
  ICCARM.CCIncludePath2: ..\..\mbedcrypto\tfm_crypto_include\mbedcrypto; ..\..\mbedcrypto\library; ..\..\trusted-firmware-m\secure_fw\partitions\crypto; ..\..\trusted-firmware-m\platform\ext\common; ..\..\trusted-firmware-m\interface\include; ..\..\..\ROM-EXPORT\mbedtls-2.17.0-rom\include; ..\..\..\ROM-EXPORT\source; ..\..\..\ROM-EXPORT\platform; $TOOLKIT_DIR$\CMSIS\Core\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\src\app
  ILINK.IlinkOutputFile: Wlanlib.out
  group psacrypto
    ../../mbedcrypto/library/: psa_crypto.c psa_crypto_se.c psa_crypto_slot_management.c psa_crypto_storage.c psa_its_file.c
