# Keil uVision project Project_PROT.uvprojx, settings and files
target Target_AN521 (6090000::V6.9::.\ARMCLANG)
  device: ARMCM33_TZ ARM
  pack: ARM.CMSIS.5.3.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") TZ CLOCK(12000000) ESEL ELITTLE
  output: prot
  AfterMake: prot_afterbuild.bat An521
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: TFM_PARTITION_PLATFORM TFM_PARTITION_AUDIT_LOG TFM_LVL=1 __thumb2__ DAUTH_CHIP_DEFAULT SST_ENCRYPTION SST_ROLLBACK_PROTECTION SST_VALIDATE_METADATA_FROM_FLASH SST_CREATE_FLASH_LAYOUT ITS_CREATE_FLASH_LAYOUT, PLATFORM_MSP_AN521, TFM_CORE_DEBUG
  c include: ..\..\..\trusted-firmware-m;..\..\..\trusted-firmware-m\interface\include\;..\..\..\trusted-firmware-m\platform\ext\cmsis;..\..\..\trusted-firmware-m\platform\ext\common;..\..\..\trusted-firmware-m\platform\ext\driver;..\..\..\trusted-firmware-m\platform\ext\target\mps2\an521\partition;..\..\..\trusted-firmware-m\platform\include;..\..\..\trusted-firmware-m\secure_fw\core;..\..\..\trusted-firmware-m\secure_fw\spm;..\..\..\trusted-firmware-m\secure_fw\core\arch\include;..\..\..\trusted-firmware-m\secure_fw\core\ipc;..\..\..\trusted-firmware-m\secure_fw\core\ipc\include;..\..\..\trusted-firmware-m\platform\ext\target\mps2\an521;..\..\..\trusted-firmware-m\platform\ext\target\mps2\an521\native_drivers;..\..\..\trusted-firmware-m\platform\ext\target\mps2\an521\cmsis_core;..\..\..\trusted-firmware-m\platform\ext\target\mps2\an521\cmsis_drivers;..\..\..\trusted-firmware-m\platform\ext\target\mps2\an521\services;..\..\..\trusted-firmware-m\platform\ext\target\mps2\an521\retarget;..\..\..\trusted-firmware-m\secure_fw\core\include;..\..\..\trusted-firmware-m\secure_fw\include;..\..\..\..\config;..\..\..\..\ROM\source;..\..\..\..\ROM\platform
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: ..\..\..\trusted-firmware-m\platform\ext\common\armclang\tfm_common_s.sct
  link misc: --predefine="-DTFM_LVL=1" --predefine="-DPLATFORM_AN521" --import_cmse_lib_out=.\An521\Objects\s_veneers.o --entry=Reset_Handler
  group partitions/audit_logging
    ../../../trusted-firmware-m/secure_fw/partitions/audit_logging/: audit_core.c tfm_audit_secure_api.c
  group patitions/crypto
    ../../../trusted-firmware-m/secure_fw/partitions/crypto/: crypto_aead.c crypto_alloc.c crypto_asymmetric.c crypto_cipher.c crypto_hash.c crypto_init.c crypto_key.c crypto_key_derivation.c crypto_mac.c tfm_crypto_secure_api.c
  group partitions/initial_attestation
    ../../../trusted-firmware-m/secure_fw/partitions/initial_attestation/: attest_token.c attestation_core.c attestation_key.c tfm_attestation.c tfm_attestation_req_mngr.c tfm_attestation_secure_api.c
  group partitions/internal_trusted_storage
    ../../../trusted-firmware-m/secure_fw/partitions/internal_trusted_storage/: its_utils.c tfm_internal_trusted_storage.c tfm_its_req_mngr.c tfm_its_secure_api.c
    ../../../trusted-firmware-m/secure_fw/partitions/internal_trusted_storage/flash_fs/: its_flash_fs.c its_flash_fs_dblock.c its_flash_fs_mblock.c
    ../../../trusted-firmware-m/secure_fw/partitions/internal_trusted_storage/flash/: its_flash.c its_flash_info_external.c its_flash_info_internal.c its_flash_nand.c its_flash_nor.c its_flash_ram.c
  group partitions/lib
    ../../../trusted-firmware-m/secure_fw/partitions/lib/sprt/: tfm_libsprt_c_memcmp.c tfm_libsprt_c_memcpy.c tfm_libsprt_c_memmove.c
  group partitions/platform
    ../../../trusted-firmware-m/secure_fw/partitions/platform/: platform_sp.c tfm_platform_secure_api.c
  group partitions/protected_storage
    ../../../trusted-firmware-m/secure_fw/partitions/protected_storage/: ps_encrypted_object.c ps_object_system.c ps_object_table.c ps_utils.c tfm_protected_storage.c tfm_ps_req_mngr.c tfm_ps_secure_api.c
    ../../../trusted-firmware-m/secure_fw/partitions/protected_storage/nv_counters/: ps_nv_counters.c
    ../../../trusted-firmware-m/secure_fw/partitions/protected_storage/crypto/: ps_crypto_interface.c
  group spm/init
    ../../../trusted-firmware-m/secure_fw/spm/init/: tfm_boot_data.c tfm_core.c
  group spm/model_func
    ../../../trusted-firmware-m/secure_fw/spm/model_func/: spm_func.c tfm_core_svcalls_func.c tfm_nspm_func.c
  group spm/model_ipc
    ../../../trusted-firmware-m/secure_fw/spm/model_ipc/: spm_ipc.c spm_psa_client_call.c tfm_core_svcalls_ipc.c tfm_message_queue.c tfm_multi_core.c tfm_multi_core_mem_check.c tfm_nspm_ipc.c tfm_pools.c tfm_rpc.c tfm_spe_mailbox.c tfm_thread.c tfm_wait.c
  group spm/runtime
    ../../../trusted-firmware-m/secure_fw/spm/runtime/: spm_api.c tfm_core_mem_check.c tfm_core_utils.c tfm_secure_api.c tfm_spm_services.c tfm_utils.c
  group spm/arch
    ../../../trusted-firmware-m/secure_fw/spm/arch/: tfm_arch.c tfm_arch_v8m_main.c
  group platform/common
    ../../../trusted-firmware-m/platform/ext/common/: tfm_platform.c
    ../../../trusted-firmware-m/platform/ext/common/template/: crypto_keys.c nv_counters.c tfm_initial_attestation_key_material.c tfm_rotpk.c attest_hal.c
  group lib/ext/t_cose
    ../../../trusted-firmware-m/lib/ext/t_cose/src/: t_cose_mac0_sign.c t_cose_mac0_verify.c t_cose_parameters.c t_cose_sign1_sign.c t_cose_sign1_verify.c t_cose_util.c
    ../../../trusted-firmware-m/lib/ext/t_cose/crypto_adapters/: t_cose_psa_crypto.c
  group lib/ext/qcbor
    ../../../trusted-firmware-m/lib/ext/qcbor/src/: ieee754.c qcbor_decode.c qcbor_encode.c UsefulBuf.c
    ../../../trusted-firmware-m/lib/ext/qcbor/util/: qcbor_util.c
  group ns_callable
    ../../../mbedtls_ns_callable/: mbedtls_nsc.c
    ../../../trusted-firmware-m/secure_fw/spm/model_func/: tfm_veneers.c
    ../../../trusted-firmware-m/secure_fw/spm/model_ipc/: tfm_psa_api_veneers.c
  group mbedtls
    ../../../../ROM-EXPORT/symbol/: rom_symbol_mbedtls_20200709
    ./: psacrypto.lib
  group log
    ../../../trusted-firmware-m/interface/src/log/: tfm_log_raw.c
  group test
    ../../../trusted-firmware-m/test/framework/: secure_suites.c test_framework.c test_framework_helpers.c test_framework_integ_test_helper.c
    ../../../trusted-firmware-m/test/suites/attestation/secure/: attestation_s_interface_testsuite.c
    ../../../trusted-firmware-m/test/suites/attestation/: attest_public_key.c attest_symmetric_iat_decode.c attest_token_decode.c attest_token_decode_common.c attest_token_test.c
    ../../../trusted-firmware-m/test/suites/audit/secure/: audit_s_interface_testsuite.c
    ../../../trusted-firmware-m/test/suites/crypto/: crypto_tests_common.c
    ../../../trusted-firmware-m/test/suites/crypto/secure/: crypto_sec_interface_testsuite.c
    ../../../trusted-firmware-m/test/suites/its/: its_tests_common.c
    ../../../trusted-firmware-m/test/suites/its/secure/: psa_its_s_interface_testsuite.c psa_its_s_reliability_testsuite.c
    ../../../trusted-firmware-m/test/suites/platform/: platform_tests_common.c
    ../../../trusted-firmware-m/test/suites/platform/secure/: platform_s_interface_testsuite.c
    ../../../trusted-firmware-m/test/suites/ps/secure/: ps_rollback_protection_testsuite.c psa_ps_s_interface_testsuite.c psa_ps_s_reliability_testsuite.c
    ../../../trusted-firmware-m/test/suites/ps/secure/nv_counters/: test_ps_nv_counters.c
    ../../../trusted-firmware-m/test/test_services/tfm_secure_client_2/: tfm_secure_client_2.c tfm_secure_client_2_api.c
    ../../../trusted-firmware-m/test/test_services/tfm_secure_client_service/: tfm_secure_client_service.c tfm_secure_client_service_api.c
    ../../../trusted-firmware-m/test/test_services/tfm_ps_test_service/: tfm_ps_test_service.c tfm_ps_test_service_api.c
  group gdm32
    ../../../trusted-firmware-m/platform/ext/target/gdm32/gd32w51x/armclang/: startup_cmsdk_s.s
    ../../../../NSPE/Firmware/CMSIS/GD/GD32W51x/Source/: system_gd32w51x.c
    ../../../trusted-firmware-m/platform/ext/common/: uart_stdout.c
    ../../../../NSPE/Firmware/GD32W51x_standard_peripheral/Source/: gd32w51x_fmc.c gd32w51x_gpio.c gd32w51x_icache.c gd32w51x_qspi.c gd32w51x_rcu.c gd32w51x_trng.c gd32w51x_tzpcu.c gd32w51x_usart.c gd32w51x_misc.c
    ../../../trusted-firmware-m/platform/ext/target/gdm32/gd32w51x/: spm_hal.c target_cfg.c
    ../../../trusted-firmware-m/platform/ext/target/gdm32/gd32w51x/native_drivers/timer_cmsdk/: timer_cmsdk.c
    ../../../trusted-firmware-m/platform/ext/target/gdm32/gd32w51x/cmsis_drivers/: Driver_Flash.c Driver_MPC.c Driver_PPC.c Driver_USART.c
    ../../../trusted-firmware-m/platform/ext/target/gdm32/gd32w51x/native_drivers/: arm_uart_drv.c mpu_armv8m_drv.c
    ../../../trusted-firmware-m/platform/ext/target/gdm32/gd32w51x/retarget/: platform_retarget_dev.c
    ../../../trusted-firmware-m/platform/ext/target/gdm32/gd32w51x/services/src/: tfm_platform_system.c
  group an521
    ../../../trusted-firmware-m/platform/ext/target/mps2/an521/: attest_hal.c dummy_boot_seed.c dummy_crypto_keys.c dummy_device_id.c dummy_nv_counters.c spm_hal.c target_cfg.c
    ../../../trusted-firmware-m/platform/ext/target/mps2/an521/armclang/: startup_cmsdk_mps2_an521_s.s
    ../../../trusted-firmware-m/platform/ext/target/mps2/an521/cmsis_core/: system_cmsdk_mps2_an521.c
    ../../../trusted-firmware-m/platform/ext/target/mps2/an521/cmsis_drivers/: Driver_Flash.c Driver_MPC.c Driver_PPC.c Driver_USART.c
    ../../../trusted-firmware-m/platform/ext/target/mps2/an521/native_drivers/: arm_uart_drv.c mpc_sie200_drv.c mpu_armv8m_drv.c ppc_sse200_drv.c
    ../../../trusted-firmware-m/platform/ext/target/mps2/an521/native_drivers/timer_cmsdk/: timer_cmsdk.c
    ../../../trusted-firmware-m/platform/ext/target/mps2/an521/retarget/: platform_retarget_dev.c
    ../../../trusted-firmware-m/platform/ext/target/mps2/an521/services/src/: tfm_platform_system.c
    ../../../trusted-firmware-m/platform/ext/common/: tfm_initial_attestation_key_material.c uart_stdout.c
target Target_GDM32 (6090000::V6.9::.\ARMCLANG)
  device: ARMCM33_TZ ARM
  pack: ARM.CMSIS.5.3.0
  cpu: as above
  output: prot
  AfterMake: ..\..\prot_afterbuild.bat SIP "" JLINK $L @L KEIL $K
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: TFM_LVL=1  __thumb2__    DAUTH_CHIP_DEFAULT PS_ENCRYPTION PS_ROLLBACK_PROTECTION ITS_CREATE_FLASH_LAYOUT ITS_VALIDATE_METADATA_FROM_FLASH PS_VALIDATE_METADATA_FROM_FLASH PS_CREATE_FLASH_LAYOUT T_COSE_USE_PSA_CRYPTO T_COSE_DISABLE_CONTENT_TYPE T_COSE_USE_PSA_CRYPTO_FROM_TFM  BOOT_DATA_AVAILABLE  LEGACY_TFM_TLV_HEADER  TFM_PARTITION_TEST_SECURE_SERVICES  TFM_PARTITION_TEST_PS ENABLE_PROTECTED_STORAGE_SERVICE_TESTS PS_TEST_NV_COUNTERS ENABLE_INTERNAL_TRUSTED_STORAGE_SERVICE_TESTS ENABLE_CRYPTO_SERVICE_TESTS ENABLE_ATTESTATION_SERVICE_TESTS  ENABLE_PLATFORM_SERVICE_TESTS ENABLE_AUDIT_LOGGING_SERVICE_TESTS SERVICES_TEST_S  TFM_CRYPTO_TEST_ALG_CBC TFM_CRYPTO_TEST_ALG_CCM  TFM_CRYPTO_TEST_ALG_CFB  TFM_CRYPTO_TEST_ALG_CTR  TFM_CRYPTO_TEST_ALG_GCM  GD_MODIFY_TAG
  c misc: -fshort-wchar
  c include: ..\..\..\trusted-firmware-m;..\..\..\trusted-firmware-m\interface\include;..\..\..\trusted-firmware-m\platform\ext\cmsis;..\..\..\trusted-firmware-m\platform\ext\common;..\..\..\trusted-firmware-m\platform\ext\driver;..\..\..\trusted-firmware-m\platform\include;..\..\..\trusted-firmware-m\platform\ext\target\gdm32\gd32w51x;..\..\..\trusted-firmware-m\platform\ext\target\gdm32\gd32w51x\cmsis_core;..\..\..\trusted-firmware-m\platform\ext\target\gdm32\gd32w51x\cmsis_drivers;..\..\..\trusted-firmware-m\platform\ext\target\gdm32\gd32w51x\native_drivers;..\..\..\trusted-firmware-m\platform\ext\target\gdm32\gd32w51x\native_drivers\timer_cmsdk;..\..\..\trusted-firmware-m\platform\ext\target\gdm32\gd32w51x\partition;..\..\..\trusted-firmware-m\platform\ext\target\gdm32\gd32w51x\retarget;..\..\..\trusted-firmware-m\platform\ext\target\gdm32\gd32w51x\services;..\..\..\..\config;..\..\..\..\ROM-EXPORT\source;..\..\..\..\ROM-EXPORT\platform;..\..\..\..\ROM-EXPORT\mbedtls-2.17.0-rom\include;..\..\..\..\ROM-EXPORT\mbedtls-2.17.0-rom\include\mbedtls;..\..\..\..\NSPE\Firmware\GD32W51x_standard_peripheral\Include;..\..\..\..\NSPE\Firmware\CMSIS\GD\GD32W51x\Include;..\..\..\..\NSPE\WIFI_IOT\app;..\..\..\mbedtls_ns_callable;..\..\..\trusted-firmware-m\secure_fw\include;..\..\..\trusted-firmware-m\secure_fw\spm\include;..\..\..\trusted-firmware-m\secure_fw\spm\arch\include;..\..\..\trusted-firmware-m\bl2\include;..\..\..\trusted-firmware-m\lib\ext\qcbor\inc;..\..\..\trusted-firmware-m\lib\ext\t_cose\inc;..\..\..\mbedcrypto\tfm_crypto_include;..\..\..\trusted-firmware-m\secure_fw\partitions\internal_trusted_storage;..\..\..\trusted-firmware-m\secure_fw\spm\model_ipc\include;..\..\..\trusted-firmware-m\lib\ext\t_cose\src;..\..\..\trusted-firmware-m\secure_fw\partitions\protected_storage;..\..\..\trusted-firmware-m\secure_fw\partitions\crypto;..\..\..\trusted-firmware-m\lib\ext\t_cose\inc;..\..\..\trusted-firmware-m\lib\ext\qcbor\inc;..\..\..\trusted-firmware-m\secure_fw\partitions\initial_attestation;..\..\..\trusted-firmware-m\test\suites\platform;..\..\..\trusted-firmware-m\lib\ext\qcbor\util
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: as above
  link misc: --predefine="-DTFM_LVL=1" --predefine="-DGD_MODIFY_TAG"  --predefine="-DPLATFORM_GDM32" --import_cmse_lib_out=.\Gdm32\Objects\s_veneers.o --entry=Reset_Handler
