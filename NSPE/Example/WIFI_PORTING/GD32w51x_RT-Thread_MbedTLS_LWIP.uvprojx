# Keil uVision project GD32w51x_RT-Thread_MbedTLS_LWIP.uvprojx, settings and files
target GD32W51x_RTT (6090000::V6.9::.\ARMCLANG)
  device: ARMCM33_DSP_FP_TZ ARM
  pack: ARM.CMSIS.5.3.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: gd32w51x +hex
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: PLATFORM_OS_RTTHREAD
  c misc: -fshort-wchar
  c include: ..\..\Template;..\..\Application;..\..\..\Demo\FreeRTOS\Source\include;..\..\..\Platform\CMSIS\GD\GD32W51x\Include;..\..\..\Port\Bsp;..\..\..\Port\OS;..\..\..\Wifi\Bsp;..\..\..\Wifi\Common;..\..\..\Wifi\Inc;..\..\..\Wifi\Manager;..\..\..\Platform\CMSIS\GD\GD32W51x\Include;..\..\..\Platform\Drivers\Include;..\..\..\Demo\Lwip\lwip-2.1.2\apps;..\..\..\Demo\Lwip\lwip-2.1.2\src\include;..\..\..\Demo\Lwip\lwip-2.1.2\src\include\lwip;..\..\..\Platform\CMSIS\DSP_Lib_v1.6.0\include;..\..\..\Port\Config;..\..\..\Port\Lwip;..\..\..\Port\Lwip\arch;..\..\..\Port\Lwip;..\..\Mbedtls\mbedtls-2.17.0\include;..\..\Mbedtls\mbedtls-2.17.0\include\mbedtls;..\..\RT-Thread\rt-thread-v4.0.3\bsp\gd32w51x;..\..\RT-Thread\rt-thread-v4.0.3\include;..\..\RT-Thread\rt-thread-v4.0.3\components\drivers\pm;..\..\RT-Thread\rt-thread-v4.0.3\components\drivers\include;..\..\RT-Thread\rt-thread-v4.0.3\bsp\gd32w51x\drivers
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\Project_RT-Thread_MbedTLS_LWIP.sct
  group Wifi
    ../../../Wifi/Bsp/: bsp_wlan.c
    ../../../Wifi/Common/: debug_print.c delay.c dlist.c wakelock.c
    ../../../Wifi/Lib/: wlan.lib
    ../../../Wifi/Manager/: wifi_eloop.c wifi_management.c wifi_netlink.c
  group Port\Bsp
    ../../../Port/Bsp/: dma.c flash_api.c gd32_it.c rf_efuse.c trng.c uart.c
  group Port\Lwip
    ../../../Port/Lwip/: dhcpd.c ethernetif.c sys_arch.c wifi_netif.c
  group Port\OS
    ../../../Port/OS/: wrapper_os.c
  group Platform\Drivers
    ../../../Platform/Drivers/Source/: gd32w51x_adc.c gd32w51x_cau.c gd32w51x_cau_aes.c gd32w51x_cau_des.c gd32w51x_cau_tdes.c gd32w51x_crc.c gd32w51x_dbg.c gd32w51x_dci.c gd32w51x_dma.c gd32w51x_efuse.c gd32w51x_exti.c gd32w51x_fmc.c gd32w51x_fwdgt.c gd32w51x_gpio.c gd32w51x_hau.c gd32w51x_hau_sha_md5.c gd32w51x_hpdf.c gd32w51x_i2c.c gd32w51x_icache.c gd32w51x_misc.c gd32w51x_pkcau.c gd32w51x_pmu.c gd32w51x_qspi.c gd32w51x_rcu.c gd32w51x_rtc.c gd32w51x_sdio.c gd32w51x_spi.c gd32w51x_sqpi.c gd32w51x_syscfg.c gd32w51x_timer.c gd32w51x_trng.c gd32w51x_tsi.c gd32w51x_tzpcu.c gd32w51x_usart.c gd32w51x_wwdgt.c
  group Platform\CMSIS
    ../../../Platform/CMSIS/GD/GD32W51x/Source/: system_gd32w51x.c
    ../../../Platform/CMSIS/GD/GD32W51x/Source/ARM/: startup_gd32w51x.s
  group Platform\DSP
    ../../../Platform/CMSIS/DSP_Lib_v1.6.0/source/: arm_bitreversal.c arm_cfft_f32.c arm_cfft_radix2_f32.c arm_cfft_radix4_f32.c arm_cfft_radix8_f32.c arm_common_tables.c arm_const_structs.c arm_cos_f32.c arm_sin_cos_f32.c arm_sin_f32.c arm_bitreversal2.S
  group Demo\Lwip
    ../../Lwip/lwip-2.1.2/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../Lwip/lwip-2.1.2/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../Lwip/lwip-2.1.2/apps/ping/: ping.c
    ../../Lwip/lwip-2.1.2/src/netif/: ethernet.c
    ../../Lwip/lwip-2.1.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group Demo\Application
    ../../Application/: console.c main.c mbedtls_init.c
  group Demo\MbedTLS
    ../../Mbedtls/mbedtls-2.17.0/library/: aes.c aes_alt.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c des_alt.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md_wrap.c md2.c md4.c md5.c memory_buffer_alloc.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs11.c pkcs12.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_self_test.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group Demo\RT-Thread
    ../../RT-Thread/rt-thread-v4.0.3/bsp/gd32w51x/drivers/: board.c
    ../../RT-Thread/rt-thread-v4.0.3/components/drivers/pm/: pm.c pm_sleep.c
    ../../RT-Thread/rt-thread-v4.0.3/libcpu/arm/cortex-m33/: context_rvds.S cpuport.c syscall_rvds.S trustzone.c
    ../../RT-Thread/rt-thread-v4.0.3/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c slab.c thread.c timer.c
software components: CMSIS:CORE 5.1.1
