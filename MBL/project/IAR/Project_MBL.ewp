# IAR project Project_MBL.ewp, settings and files
configuration GDM32 (ARM)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: PLATFORM_GDM32
  ICCARM.CCDiagSuppress: Pa050,Pe223,Pe177
  ICCARM.IExtraOptions: --enum_is_int
  ICCARM.CCIncludePath2: ..\..\source; ..\..\platform; ..\..\platform\gdm32; ..\..\..\config; ..\..\..\ROM-EXPORT\mbedtls-2.17.0-rom\include; ..\..\..\ROM-EXPORT\platform; ..\..\..\ROM-EXPORT\source; ..\..\..\NSPE\Firmware\CMSIS\GD\GD32W51x\Include; ..\..\..\NSPE\Firmware\GD32W51x_standard_peripheral\Include; $TOOLKIT_DIR$\CMSIS\Core\Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\inc; ..\src\app
  OBJCOPY.OOCOutputFile: Project_MBL.srec
  prebuild: mbl_prebuild.bat TZ $PROJ_DIR$ "$TOOLKIT_DIR$"
  postbuild: ..\mbl_afterbuild_tz.bat SIP "" DAPLINK $TARGET_DIR$ $TARGET_BNAME$ IAR "$TOOLKIT_DIR$"
  ILINK.IlinkOutputFile: mbl.axf
  ILINK.IlinkIcfFile: mbl_gdm32.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group bootloader
    ../../source/: mbl.c mbl_image_validate.c mbl_nsc_api.c mbl_status.c mbl_target_config.c
  group gdm32
    ../../../NSPE/Firmware/GD32W51x_standard_peripheral/Source/: gd32w51x_fmc.c gd32w51x_gpio.c gd32w51x_icache.c gd32w51x_misc.c gd32w51x_rcu.c gd32w51x_tzpcu.c gd32w51x_usart.c
    ../../platform/gdm32/: gd32w51x_it.c
    ../../platform/gdm32/iar/: mbl_startup_gdm32.s
    ../../platform/gdm32/cmsis_core/: mbl_system_gdm32.c
