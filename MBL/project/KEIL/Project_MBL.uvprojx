# Keil uVision project Project_MBL.uvprojx, settings and files
target Target_AN521 (6090000::V6.9::.\ARMCLANG)
  device: ARMCM33_TZ ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") TZ CLOCK(12000000) ESEL ELITTLE
  output: mbl +hex
  AfterMake: mbl_afterbuild.bat An521
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: PLATFORM_MSP_AN521
  c include: ..\..\source;..\..\platform;..\..\..\ROM\source;..\..\..\ROM\platform;..\..\..\ROM\platform\cmsis;..\..\..\ROM\platform\msp2-an521\cmsis_core;..\..\..\ROM\platform\msp2-an521\retarget;..\..\..\config;..\..\..\ROM\mbedtls-2.17.0\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: ..\..\platform\msp2-an521\armclang\mbl_an521.sct
  link misc: --predefine="-DPLATFORM_MSP_AN521" --import-cmse-lib-out=".\An521\Objects\mbl_CMSE_Lib.o"
  group bootloader
    ../../source/: mbl.c mbl_image_validate.c mbl_status.c mbl_target_config.c mbl_nsc_api.c
    ../../../ROM/project/MDK-ARM/: rom_symbol_mbedtls
    ../../../ROM-EXPORT/symbol/: rom_symbol_mbedtls_20200709
  group an521
    ../../platform/msp2-an521/cmsis_core/: mbl_system_an521.c
    ../../platform/msp2-an521/armclang/: mbl_startup_an521.s
  group gdm32
    ../../platform/gdm32/armclang/: mbl_startup_gdm32.s
    ../../platform/gdm32/cmsis_core/: mbl_system_gdm32.c
    ../../../NSPE/Firmware/GD32W51x_standard_peripheral/Source/: gd32w51x_fmc.c gd32w51x_gpio.c gd32w51x_icache.c gd32w51x_misc.c gd32w51x_rcu.c gd32w51x_usart.c gd32w51x_tzpcu.c
    ../../platform/gdm32/: gd32w51x_it.c
target Target_GDM32 (6090000::V6.9::.\ARMCLANG)
  device: ARMCM33_DSP_FP_TZ ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: mbl
  AfterMake: ..\mbl_afterbuild_tz.bat SIP "" JLINK $L @L KEIL $K
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: PLATFORM_GDM32,
  c include: ..\..\source;..\..\platform;..\..\platform\gdm32;..\..\..\config;..\..\..\ROM-EXPORT\source;..\..\..\ROM-EXPORT\platform;..\..\..\ROM-EXPORT\mbedtls-2.17.0-rom\include;..\..\..\NSPE\Firmware\CMSIS\GD\GD32W51x\Include;..\..\..\NSPE\Firmware\GD32W51x_standard_peripheral\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: ..\..\platform\gdm32\armclang\mbl_gdm32.sct
  link misc: --predefine="-DPLATFORM_GDM32" --import-cmse-lib-out=".\mbl\Objects\mbl_cmse_Lib.o"
software components: CMSIS:CORE 5.1.1
